# Keil uVision project STM32H7B3I-DK.uvprojx, settings and files
target STM32H7B3I-DK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM(0x24000000-0x240FFFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H7B3I-DK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H7B3xxQ,USE_BPP=24
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common;../Drivers/BSP/STM32H7B3I-DK;../LIBJPEG/App;../LIBJPEG/Target;../Utilities/JPEG;../Middlewares/Third_Party/LibJPEG/include;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc;../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: STM32H7B3I-DK.sct
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: tgfx_jpeg_utils.c TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/BSP/STM32H7B3I-DK
    ../Drivers/BSP/STM32H7B3I-DK/: stm32h7b3i_discovery_ospi.c stm32h7b3i_discovery_ts.c stm32h7b3i_discovery_bus.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_ospi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../touchgfx/gui/src/model/: model.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/main_screen/: mainviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Application/User/LIBJPEG/App
    ../LIBJPEG/App/: libjpeg.c
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jcapimin.c jcapistd.c jdapimin.c jdapistd.c jcomapi.c jcparam.c jctrans.c jdtrans.c jcinit.c jcmaster.c jcmainct.c jcprepct.c jccoefct.c jccolor.c jcsample.c jcdctmgr.c jfdctint.c jfdctfst.c jfdctflt.c jchuff.c jcarith.c jcmarker.c jdatadst.c jdmaster.c jdinput.c jdmainct.c jdcoefct.c jdpostct.c jdmarker.c jdhuff.c jdarith.c jddctmgr.c jidctint.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jdmerge.c jquant1.c jquant2.c jdatasrc.c jaricom.c jerror.c jmemmgr.c jutils.c jmemnobs.c
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
  group Sources
    ../../Jerry Project/trunk/: Init-STM32H7B3I-DK.cpp Init-STM32H7B3I-DK-ExtMem.cpp Init-STM32H7B3I-DK-IOPins.cpp STM32H7B3I-DK.cpp
  group Setup
    ../../Jerry Project/trunk/Controller/Setup/Src/: Guard.cpp Heap.cpp Mutex.cpp Retarget.cpp Vectors.cpp
  group Cortex-M7
    ../../Jerry Project/trunk/Controller/Cortex-M7/Src/: Cortex-M7.cpp Cortex-M7-Caches.cpp Cortex-M7-Faults.cpp Cortex-M7-MPU.cpp Cortex-M7-Regs.cpp Cortex-M7-STK.cpp Init-Cortex-M7.cpp ItmSend.cpp Reset.cpp
  group STM32H7B3
    ../../Jerry Project/trunk/Controller/STM32H7B3/Src/: Init-STM32H7B3.cpp STM32H7B3.cpp STM32H7B3-Clocks.cpp STM32H7B3-Debug.cpp
  group HAL
    ../../Jerry Project/trunk/HAL/Src/: ImplementationGpio.cpp ImplementationGpio.h ImplementationGpioA.cpp ImplementationGpioC.cpp ImplementationGpioG.cpp ImplementationUart.cpp ImplementationUart.h ImplementationUart1.cpp
  group Debug
    ../../Jerry Project/trunk/Utilities/Src/: Debug.cpp Formatter.cpp UBSan.cpp
software components: CMSIS:CORE 6.1.0
